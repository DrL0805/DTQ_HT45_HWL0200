# Keil uVision project drl51822project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DTQ_HT45_HWL_SSLK_V0005 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\components\drivers_nrf\hal;..\components\drivers_nrf\delay;..\components\drivers_nrf\nrf_soc_nosd;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\adc;..\components\drivers_nrf\wdt;..\components\drivers_nrf\clock;..\components\libraries\timer;..\components\libraries\scheduler;..\components\libraries\util;..\components\libraries\fifo;..\components\toolchain\CMSIS\Include;..\components\toolchain;..\components\properitary_rf\esb;..\user;..\user\clock;..\user\timers;..\user\uart;..\user\led;..\user\lcd;..\user\key;..\user\application;..\user\power;..\user\radio;..\user\adc;..\user\attend;..\user\flash;..\user\test;..\user\match;..\user\w25qxx;..\user\M24SR;..\user\watchdog;..\user\drl_lib;..\components\drivers_nrf\timer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group drl_lib
    ../user/drl_lib/: drl_err.c drl_debug.c drl_common.c drl_library.h drl_timer.c
    ../user/timers/: timer_0.c
  group user
    ../user/: main.c
    ../user/timers/: timers.c
    ../user/uart/: simple_uart.c uart.c
    ../user/clock/: clock.c
    ../user/led/: led.c
    ../user/lcd/: lcd_drv.c lcd_lib.c
    ../user/key/: key.c
    ../user/application/: application.c
    ../user/power/: power.c
    ../user/radio/: radio.c
    ../user/adc/: adc.c
    ../user/attend/: attend.c
    ../user/flash/: flash.c
    ../user/test/: test.c
    ../user/match/: match.c
    ../user/w25qxx/: w25qxx.c spi_master.c
    ../user/M24SR/: drv_I2C_M24SR.c drv_M24SR.c lib_M24SR.c lib_NDEF.c lib_TagType4.c
    ../user/watchdog/: watchdog.c
  group nrf_lib
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/properitary_rf/esb/: nrf_esb.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c app_util_platform.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/adc/: nrf_drv_adc.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
  group device
    ../components/toolchain/: system_nrf51.c
    ../components/toolchain/arm/: arm_startup_nrf51.s
  group include
    ../user/: main.h
    ../user/application/: application.h
    ../user/drl_lib/: drl_err.h
    ../user/lcd/: lcd_drv.h lcd_lib.h
